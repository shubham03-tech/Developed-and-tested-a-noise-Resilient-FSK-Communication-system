options:
  parameters:
    generate_options: qt_gui
    id: video_with_fsk_transmitter
    output_language: python
    title: video_transmitter
  states: {}

blocks:
- name: channel_bw
  id: variable
  parameters:
    value: '3000000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '910000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\shubh\OneDrive\Desktop\FSK-GnuRadio\output_video.ts
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\shubh\OneDrive\Desktop\FSK-GnuRadio\video1.ts
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '5000'
    type: complex
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (8, 2048)
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,0,1,0,1,0,1,0)
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5566
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_file_sink_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', zeromq_pub_sink_0, '0']
- [blocks_stream_mux_0, '0', digital_gfsk_mod_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_stream_mux_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '1']
- [digital_gfsk_mod_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
