options:
  parameters:
    generate_options: hb
    id: new_hier
    output_language: python
    title: FSK_CUST_BB
  states: {}

blocks:
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '54'
    type: float
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '8'
    init: '0'
    low: '7'
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: np.cos(2*np.pi*np.arange(0,9)/9)
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '72'
    in_type: byte
    out_type: float
    symbol_table: ' np.concatenate((np.cos(2*np.pi*f0*np.arange(0,72)/72),np.cos(2*np.pi*f1*np.arange(0,72)/72)))'
  states: {}
- name: f0
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: f1
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '72'
    taps: np.cos(2*np.pi*np.arange(0,72)/72)
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '256000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '512000'
    win: window.WIN_HAMMING
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: fsktx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: fsktx
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', low_pass_filter_0, '0']
- [blocks_delay_0, '0', fir_filter_xxx_0, '0']
- [blocks_float_to_char_0, '0', pad_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_char_0, '0']
- [blocks_vector_source_x_1, '0', blocks_multiply_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', virtual_sink_0, '0']
- [fir_filter_xxx_0, '0', blocks_threshold_ff_0, '0']
- [low_pass_filter_0, '0', blocks_delay_0, '0']
- [pad_source_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
