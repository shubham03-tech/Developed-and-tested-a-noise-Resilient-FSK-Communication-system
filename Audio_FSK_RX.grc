options:
  parameters:
    generate_options: qt_gui
    id: Audio_FSK_RX
    output_language: python
    title: Audio_fsk_rx
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '9216000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '128'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '54'
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '6'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '8'
    init: '0'
    low: '7'
  states: {}
- name: f0
  id: parameter
  parameters:
    value: '8'
  states: {}
- name: f1
  id: parameter
  parameters:
    value: '9'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '72'
    taps: np.cos(2*np.pi*np.arange(0,72)/72)
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '256000'
    decim: '1'
    gain: '1'
    samp_rate: '9216000'
    type: fir_filter_fff
    width: '512000'
    win: window.WIN_HAMMING
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '5556'
    src_zeros: 'False'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', low_pass_filter_0, '0']
- [blocks_char_to_float_1, '0', audio_sink_0, '0']
- [blocks_delay_0, '0', fir_filter_xxx_0, '0']
- [blocks_delay_0_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_float_to_char_0, '0', blocks_delay_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_char_to_float_1, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_char_0, '0']
- [fir_filter_xxx_0, '0', blocks_threshold_ff_0, '0']
- [low_pass_filter_0, '0', blocks_delay_0, '0']
- [network_udp_source_0, '0', blocks_add_xx_0, '0']
- [network_udp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
