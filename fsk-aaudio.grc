options:
  parameters:
    generate_options: qt_gui
    id: fsk_audio
    output_language: python
    title: fsk_audio
  states: {}

blocks:
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '128'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '6'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '128'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\shubh\OneDrive\Desktop\FSK-GnuRadio\random_song1.wav
    repeat: 'True'
  states: {}
- name: new_hier_0
  id: new_hier
  parameters:
    f0: '8'
    f1: '9'
    samp_rate: '9216000'
  states: {}

connections:
- [blocks_char_to_float_0, '0', audio_sink_0, '0']
- [blocks_delay_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_float_to_char_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', new_hier_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_char_0, '0']
- [new_hier_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
