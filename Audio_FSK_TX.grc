options:
  parameters:
    generate_options: qt_gui
    id: Audio_FSK_TX
    output_language: python
    title: Audio_Fsk_tx
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '9216000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '16000'
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '128'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: np.cos(2*np.pi*np.arange(0,9)/9)
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\shubh\OneDrive\Desktop\FSK-GnuRadio\random_song1.wav
    repeat: 'True'
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '72'
    in_type: byte
    out_type: float
    symbol_table: ' np.concatenate((np.cos(2*np.pi*f0*np.arange(0,72)/72),np.cos(2*np.pi*f1*np.arange(0,72)/72)))'
  states: {}
- name: f0
  id: parameter
  parameters:
    value: '8'
  states: {}
- name: f1
  id: parameter
  parameters:
    value: '9'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 10.96.2.180
    header: '0'
    payloadsize: '1472'
    port: '50001'
    send_eof: 'False'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: fsktx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: fsktx
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: udp://10.96.2.180:50001
    timeout: '100'
    type: float
  states: {state: disabled}

connections:
- [audio_source_0, '0', blocks_float_to_char_0, '0']
- [blocks_float_to_char_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_multiply_xx_0, '0', network_udp_sink_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', zeromq_pub_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_char_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
